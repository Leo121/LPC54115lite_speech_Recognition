# Keil uVision project dmic_hwvad.uvprojx, settings and files
target dmic_hwvad Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dmic_hwvad.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54114J256BD64_cm4, ARM_MATH_CM4, __FPU_PRESENT=1,  __CC_ARM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../../CMSIS/Include;../../../../../../../devices;../../../../../../../devices/LPC54114;../../../../..;../../..;../..;../../../../../../../platform/utilities/debug_console;../../../../../../../devices/LPC54114/drivers;../../../../../../../devices/LPC54114/utilities
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: ../../../../../../../devices/LPC54114/arm/keil_lib_power.lib 
--remove
  group doc
    ../../: readme.txt
  group startup
    ../../../../../../../devices/LPC54114/arm/: startup_LPC54114_cm4.s
    ../../../../../../../devices/LPC54114/: system_LPC54114_cm4.c system_LPC54114_cm4.h
  group drivers
    ../../../../../../../devices/LPC54114/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_dmic.c fsl_dmic.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_inputmux.h fsl_inputmux.c fsl_reset.h fsl_reset.c fsl_dma.c fsl_dma.h fsl_dmic_dma.c fsl_dmic_dma.h
    ../../: app_dmic.c app_dmic.h app_key.c app_key.h app_led.c app_led.h
  group source
    ../../: dmic_hwvad.c dtw.c MFCC.c dtw.h MFCC.h MFCC_Arg.h VAD.c
  group board
    ../../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../../devices/LPC54114/utilities/: fsl_debug_console.c fsl_debug_console.h
target dmic_hwvad Release (ARM-ADS)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: dmic_hwvad.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC54114J256BD64_cm4
  c misc: as above
  c include: as above
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: as above
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
